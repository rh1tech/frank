File: hardware/frank_fastbeta_pwt/fastbeta_pwt.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Board updates
Other:
- sheet Power ports: added EN; removed none
